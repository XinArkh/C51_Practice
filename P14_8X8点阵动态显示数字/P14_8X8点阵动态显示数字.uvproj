# Keil uVision project P14_8X8点阵动态显示数字.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: P14_8X8点阵动态显示数字 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: LEDs.c
