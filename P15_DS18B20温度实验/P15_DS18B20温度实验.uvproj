# Keil uVision project P15_DS18B20温度实验.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: P15_DS18B20温度实验 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: ds18b20.c main.c ds18b20.h
