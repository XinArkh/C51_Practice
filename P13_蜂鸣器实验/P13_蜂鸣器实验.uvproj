# Keil uVision project P13_蜂鸣器实验.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: P13_蜂鸣器实验 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: beep.c music.h SoundPlay.h
